# Keil uVision project ANO_FLY.uvproj, settings and files
target ANO_FLY (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ANO_FLY +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\LIB;..\ANO_FLY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ./LIB/: stm32f10x_conf.h system_stm32f10x.c core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c startup_stm32f10x_md.s
  group BSP
    ./BSP/: BSP.c BSP.h Tim.c Tim.h Usart.c Usart.h Nrf24l01.h Spi.c Spi.h Led.c Led.h MPU6050.c MPU6050.h Moto.c moto.h Nrf24l01.C eeprom.c eeprom.h ADC.c ADC.h ultrasonic.c ultrasonic.H
  group APP_SYS
    ./APP/SYS/: main.c stm32f10x_it.c
    ./: stm32_config.h
  group APP_UART
    ./APP/UART/: Uart1.c Uart1.h
  group APP_RC
    ./APP/RC/: Rc.c Rc.h
  group APP_IMU
    ./APP/IMU/: IMU.c IMU.h
  group APP_CONTROL
    ./APP/CONTROL/: Control.c Control.h
  group BSP_IICLIB
    ./BSP/: STM32_I2C.c STM32_I2C.h
